inherit externalsrc
EXTERNALSRC="/home/saurabhr7/gnss/build-openstlinuxweston-stm32mp1/X-LINUX-GNSS1_V1.0.0/Application/Source/gnss_x_linux/Sources"
