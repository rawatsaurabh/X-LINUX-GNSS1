inherit externalsrc
EXTERNALSRC = "/home/saurabh/STM32MPU_workspace/gnss/recipe/new-bb/build-openstlinuxweston-stm32mp1/gnss_x_linux/Sources"
